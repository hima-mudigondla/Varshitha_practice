FILESEXTRAPATHS:prepend := "${THISDIR}/files/:"

SRC_URI += "file://0001-Add-viyara6ull-WEIM-GPMI-device-tree.patch \
		file://0002-Port-WIFI-DTS-data-from-5.10-to-6.12.patch \
"

