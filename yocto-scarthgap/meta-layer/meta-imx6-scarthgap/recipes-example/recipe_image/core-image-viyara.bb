DESCRPTION="Recipe for images"

require recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL:append=" driver"
